# Keil uVision project Project.uvprojx, settings and files
target STM32_user_application_template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_user_application_template +hex
  AfterMake: E:\Software\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o E:\STM32_user_application_template\MDK-ARM\Obj\STM32_user_application_template.bin E:\STM32_user_application_template\MDK-ARM\Obj\STM32_user_application_template.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\STM32_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\STM32_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32_Libraries\CMSIS\CM3\CoreSupport;..\STM32_Libraries\STM32F10x_StdPeriph_Driver\inc;..\USB_Dependence\inc;..\USB_Library\inc;..\User_Library\inc;..\User\inc
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../STM32_Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group STM32F10x
    ../STM32_Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group CoreSupport
    ../STM32_Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group STM32F10x_StdPeriph_Driver
    ../STM32_Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB_dependence
    ../USB_Dependence/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB_library
    ../USB_Library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group User_Library
    ../User_Library/src/: eeprom.c delay.c USB_message_process.c UART_ringFIFO.c crc.c eeprom_data_manager.c message_resolve.c message_resolve_hook.c IIC_driver.c IIC_driver_2.c device_abnormal_state_record.c SPI_driver.c
  group User
    ../User/src/: main.c stm32f10x_it.c
